# IAR project InterruptController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: E:\New folder\IAR Systems\Embedded Workbench 9.0\arm\inc\TexasInstruments; E:\New folder\IAR Systems\Embedded Workbench 9.0\arm\CMSIS\Core\Include; E:\Repos\Sprints\SprintW9\ARM_Master_Class\CPU_DriverAndCommonFolder\CPU
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: InterruptController.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CPU_Driver
    ../CPU_DriverAndCommonFolder/CPU/: CPU.c CPU.h
  group INTCTRL
    INTCTRL/: INTCTRL.c INTCTRL.h INTCTRL_Cfg.h INTCTRL_Lcfg.c
